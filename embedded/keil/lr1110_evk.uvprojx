# Keil uVision project lr1110_evk.uvprojx, settings and files
target stm32l476rg (6120000::V6.12::.\ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lr1110_evk
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER, LV_CONF_INCLUDE_SIMPLE
  c misc: -Wno-deprecated-register
  c include: ..\lr1110_driver\src;..\STM32L4xx_HAL_Driver\Inc;..\STM32L4xx_HAL_Driver\Inc\Legacy;..\CMSIS\Core\Include;..\CMSIS\Device\ST\STM32L4xx\Include;..\application\inc;..\system\inc;..\gui\inc;..\display_touch\inc;..\supervisor\inc;..\communication\inc;..\demo\inc;..\hci\Command\Inc;..\hci;..\lvgl;..\lvgl\src;..\lvgl\src\lv_core;..\lvgl\src\lv_draw;..\lvgl\src\lv_font;..\lvgl\src\lv_hal;..\lvgl\src\lv_misc;..\lvgl\src\lv_objx;..\lvgl\src\lv_themes
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group application
    ../application/src/: main.cpp lr1110_hal.c timer_interface_implementation.cpp
  group lr1110_driver
    ../lr1110_driver/src/: lr1110_bootloader.c lr1110_crypto_engine.c lr1110_radio.c lr1110_regmem.c lr1110_system.c lr1110_wifi.c lr1110_gnss.c lr1110_driver_version.c
  group stm32l4xx_hal_driver
    ../STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_spi.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c stm32l4xx_ll_i2c.c stm32l4xx_ll_dma.c stm32l4xx_ll_lptim.c
  group CMSIS
    ../CMSIS/Device/ST/STM32L4xx/Source/: system_stm32l4xx.c
    ../CMSIS/Device/ST/STM32L4xx/Source/arm/: startup_stm32l476xx.s
  group system
    ../system/src/: system_clock.c system_gpio.c system_spi.c system_uart.c system_it.c system_i2c.c system.c system_time.c system_uart_retarget.c system_lptim.c
  group display_touch
    ../display_touch/src/: display.c touch.c
  group gui
    ../gui/src/: gui.cpp guiCommon.cpp guiMenuDemo.cpp guiResultsWifi.cpp guiSplashScreen.cpp guiTestWifi.cpp guiTestGnss.cpp guiResultsGnss.cpp lv_port_disp.c semtech_logo.c lv_port_indev.c guiConfigGnss.cpp guiConfigWifi.cpp guiAbout.cpp guiMenu.cpp guiMenuRadioTestModes.cpp guiConfigRadioTestModes.cpp guiRadioTxCw.cpp guiRadioPingPong.cpp guiRadioPer.cpp guiMenuCommon.cpp
  group communication
    ../communication/src/: communication_demo.cpp communication_field_test.cpp communication_interface.cpp communication_manager.cpp communication_print_only.cpp communication_utils.cpp
  group supervisor
    ../supervisor/src/: supervisor.cpp
  group demo
    ../demo/src/: demo_base.cpp demo.cpp demo_gnss_autonomous.cpp demo_gnss_assisted.cpp demo_gnss_base.cpp environment_interface.cpp demo_wifi_interface.cpp demo_wifi_country_code.cpp demo_wifi_scan.cpp demo_tx_cw.cpp demo_ping_pong.cpp demo_radio_per.cpp demo_radio_interface.cpp device_transceiver.cpp demo_transceiver_base.cpp device_base.cpp demo_wifi_types.cpp
  group hci
    ../hci/: hci.cpp
    ../hci/Command/Src/: command_base.cpp command_factory.cpp command_fetch_result.cpp command_get_version.cpp command_reset.cpp command_set_date_loc.cpp command_start_demo.cpp command_status.cpp field_test_log.cpp command_get_almanac_dates.cpp command_check_almanac_update.cpp command_update_almanac.cpp
  group lvgl/lv_core
    ../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_debug.c
  group lvgl/lv_draw
    ../lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group lvgl/font
    ../lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
  group lvgl/lv_hal
    ../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/lv_misc
    ../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c lv_printf.c
  group lvgl/objx
    ../lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lvgl/themes
    ../lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
software components: Compiler:I/O:STDOUT 1.2.0
